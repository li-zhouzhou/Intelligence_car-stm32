# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\Car_control;..\HARDWARE\Obstacle_avoid;..\HARDWARE\Trace;..\HARDWARE\REMOTE_CTR;..\HARDWARE\BLUETOOTH_CTR;..\HARDWARE\LCD;..\HARDWARE\PS2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/Car_control/: car_control.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Obstacle_avoid/: obstacle_avoid.c
    ../HARDWARE/Trace/: trace.c
    ../HARDWARE/REMOTE_CTR/: remote_ctr.c
    ../HARDWARE/BLUETOOTH_CTR/: bluetooth_ctr.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/PS2/: ps2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_fsmc.c
  group README
    ../: readme.txt
